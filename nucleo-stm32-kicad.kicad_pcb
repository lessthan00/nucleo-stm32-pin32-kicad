# Repository lessthan00/nucleo-stm32-pin32-kicad

File README.md:

# nucleo-stm32-kicad

https://www.st.com.cn/zh/evaluation-tools/stm32-nucleo-boards.html

https://www.st.com.cn/zh/evaluation-tools/stm32-nucleo-boards/products.html?querycriteria=productId=LN1847$$1574=Nucleo-32&aggOrder=0%7C1%7C2%7C3%7C4%7C5%7C6%7C7%7C8%7C9%7C10%7C11%7C12%7C13%7C14%7C15%7C16%7C17%7C18%7C19%7C20%7C21

https://www.st.com.cn/zh/evaluation-tools/nucleo-l432kc.html#cad-resources

[datasheet](https://www.st.com/resource/en/datasheet/stm32l432kc.pdf)

这是最小开发板,为了32pin的stm32

## KiCad design nucleo-stm32-kicad.kicad_pcb

Parts:
C1, C2: 10uF; C_1206_3216Metric
C3, C4, C5, C7, C9: 100nF; C_1206_3216Metric
C6, C8: 22pF; C_0603_1608Metric
D1: SMAJ6.5CA; D_SMA_TVS
D2: SMAJ5.0CA; D_SMA_TVS
FB1: 600Ω100Mhz; Ferrite_1206_3216Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
J2, J3, J4, J6, J8: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J5, J7: Conn_01x15; PinHeader_1x15_P2.54mm_Vertical
J16: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
LED2, LED3, LED4: LED_1206; LED_1206_3216Metric
R1, R2, R3: 5.1K; R_1206_3216Metric
R4: 10K; R_1206_3216Metric
R5: R_1206; R_1206_3216Metric
SW1: SW_Push; SW_PUSH_6mm_H7.3mm
U1: STM32L432K_B-C_Ux; LQFP-32_7x7mm_P0.8mm_QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
U2: AMS1117-3.3; SOT-223-3_TabPin2
X1: Crystal_Generic_GND24; Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C3.1, C5.1, C9.1, D2.2 (A), J6.1, J8.2, J16.1, LED3.2 (A), R4.1, U1.1 (VDD), U1.17 (VDD)
/BOOT0: J2.1, R1.2
/JTDI: J5.7, J16.6, U1.25 (PA15)
/JTDO: J5.8, J16.7, U1.26 (PB3)
/NRST: C4.1, J5.13, J16.5, R4.2, SW1.2, U1.4 (NRST)
/OSC32+: C8.1, U1.2 (PC14), X1.3
/OSC32-: C6.1, U1.3 (PC15), X1.1
/PA0: J5.14, U1.6 (PA0)
/PA1: J5.15, U1.7 (PA1)
/PA2: J7.15, U1.8 (PA2)
/PA3: J7.14, U1.9 (PA3)
/PA4: J7.13, U1.10 (PA4)
/PA5: J7.12, U1.11 (PA5)
/PA6: J7.11, U1.12 (PA6)
/PA7: J7.10, U1.13 (PA7)
/PA8: J7.7, U1.18 (PA8)
/PA9: J7.6, U1.19 (PA9)
/PA10: J7.5, U1.20 (PA10)
/PB0: J7.9, U1.14 (PB0)
/PB1: J7.8, U1.15 (PB1)
/PB4: J5.9, R5.1, U1.27 (PB4)
/PB5: J5.10, U1.28 (PB5)
/PB6: J5.11, U1.29 (PB6)
/PB7: J5.12, U1.30 (PB7)
/PIN3_3V: C2.1, J6.2, J7.3, J7.4, U2.2 (VO)
/SWCLK: J5.6, J16.3, U1.24 (PA14)
/SWDIO: J5.5, J16.2, U1.23 (PA13)
/USB+: J1.A6 (D+), J1.B6 (D+), U1.22 (PA12)
/USB-: J1.A7 (D-), J1.B7 (D-), U1.21 (PA11)
/VSS2: J3.2, U1.16 (VSS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.1 (K), D2.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.1, J4.2, J5.1, J5.2, J7.1, J7.2, J16.4, LED2.1 (K), LED3.1 (K), LED4.1 (K), R1.1, R2.2, R3.2, SW1.1, U1.33 (VSS), U2.1 (GND), X1.2, X1.4
unnamed: J1.A5 (CC1), R3.1
unnamed: J1.B5 (CC2), R2.1
unnamed: J2.2, U1.31 (PH3)
unnamed: J4.1, U1.32 (VSS)
unnamed: FB1.1, J8.1
unnamed: LED4.2 (A), R5.2
VBUS: C1.1, D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J5.3, J5.4, LED2.2 (A), U2.3 (VI)
VDDA: C7.1, FB1.2, U1.5 (VDDA)

Notes on the sheet:
DAC1_OUT1
SPI1_NSS
PA12
USB_DM
PC15
USB_DP
SPI1_MISO
PC14
PA14
TIM2_CH1
PA11
PA15
I2C1_SCL
UART1_RX
PB2
ADC1_IN6
SPI1_SCK
假定晶振负载电容为12pF, 旁路电容约2*12pF=24pF, 没有覆铜,杂散电容会减小,忽略.
PA13
PIN2 PF0/PC14/MCO PIN3 PF1/PC15 PIN6 PA0/MCO PIN16 PB2/VSS2->GND PIN31 BOOT0/PB8/PH3->GND PIN32 PB8/VSS3->GND
PB3
I2C1_SDA
UART1_TX
SPI1_MOSI

Board: 2 copper layers, 32.0 x 47.0 mm, 33 parts (14 on the bottom side), 39 nets.
